# Keil uVision project ECU-RS-207.uvproj, settings and files
target ECU-RS-V2 (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32_RTT_F107RC
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\Target\ecu-r-rs.bin ..\build\STM32_RTT_F107RC.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\components\CMSIS\Include;..\components\DeviceDrivers;..\components\finsh;..\components\net\lwip-1.4.1\src;..\components\net\lwip-1.4.1\src\arch\include;..\components\net\lwip-1.4.1\src\include;..\components\net\lwip-1.4.1\src\include\ipv4;..\components\net\lwip-1.4.1\src\netif;..\rtt\include;..\libcpu\arm\common;..\libcpu\arm\cortex-m3;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\applications;..\drivers;..\components\net\ethernet;..\applications;..\components\armlibc;..\..\ECU-RS-V2;..\ECU\ECUDBG\inc;..\components\DeviceDrivers\CMT2300;..\components\DeviceDrivers\EEPROM;..\components\DeviceDrivers\KEY;..\components\DeviceDrivers\LED;..\components\DeviceDrivers\Net;..\components\DeviceDrivers\rtc;..\components\DeviceDrivers\SYSTEM\sys;..\components\DeviceDrivers\SYSTEM\usart;..\components\DeviceDrivers\TIMER;..\components\DeviceDrivers\watchdog;..\ECU\ECUComm\inc;..\ECU\ECUEvent\inc;..\ECU\Other\APPComm;..\ECU\Other\EVENT;..\ECU\Other\FILE;..\ECU\Other\Inverter;..\ECU\Other\RFM300H;..\ECU\Other;..\ECU\ECUServer\inc;..\components\dfs\include;..\components\dfs\filesystems\elmfat;..\ECU\Other\socket;..\ECU\Other\Serverfile;..\ECU\Other\dateTime;..\ECU\ECUControl\inc;..\ECU\ECUCollect\inc;..\ECU\ECUClient\inc;..\ECU\ECUUpdate\inc;..\components\FTP
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ../applications/: application.c startup.c threadlist.c
  group STM32_StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_tim.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Kernel
    ../rtt/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c udelay.c
  group CORTEX-M3
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../components/net/ethernet/: stm32_eth.c
    ../components/DeviceDrivers/CMT2300/: CMT2300.c
    ../components/DeviceDrivers/EEPROM/: Flash_24L512.c
    ../components/DeviceDrivers/KEY/: key.c
    ../components/DeviceDrivers/LED/: led.c
    ../components/DeviceDrivers/Net/: lan8720rst.c
    ../components/DeviceDrivers/rtc/: ds1302z_rtc.c rtc.c
    ../components/DeviceDrivers/SYSTEM/sys/: sys.c
    ../components/DeviceDrivers/SYSTEM/usart/: serial.c usart.c usart5.c
    ../components/DeviceDrivers/TIMER/: timer.c
    ../components/DeviceDrivers/watchdog/: watchdog.c
    ../components/DeviceDrivers/: board.c completion.c cpuusage.c dataqueue.c stm32f10x_it.c spi_core.c spi_dev.c spi_flash_w25qxx.c platform.c rt_stm32f10x_spi.c
    ../components/FTP/: thftpapi.c
  group finish
    ../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LwIP
    ../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group LIBC
    ../components/armlibc/: libc_syms.c mem_std.c stubs.c
  group FileSystem
    ../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group ECUDEBUG
    ../ECU/ECUDBG/src/: SEGGER_RTT.c SEGGER_RTT_printf.c debug.c
  group Other
    ../ECU/Other/APPComm/: appcomm.c
    ../ECU/Other/EVENT/: event.c
    ../ECU/Other/FILE/: file.c
    ../ECU/Other/Inverter/: inverter.c
    ../ECU/Other/RFM300H/: RFM300H.c
    ../ECU/Other/dateTime/: datetime.c
    ../ECU/Other/Serverfile/: serverfile.c
    ../ECU/Other/socket/: socket.c
  group ECUComm
    ../ECU/ECUComm/src/: ECUComm.c
  group ECUEvent
    ../ECU/ECUEvent/src/: ECUEvent.c AppFunction.c
  group ECUCollect
    ../ECU/ECUCollect/src/: ECUCollect.c
  group ECUClient
    ../ECU/ECUClient/src/: ECUClient.c
  group ECUControl
    ../ECU/ECUControl/src/: ECUControl.c remote_control_protocol.c set_rsd_function_switch.c custom_command.c mycommand.c inverter_id.c
  group ECUUpdate
    ../ECU/ECUUpdate/src/: flash_if.c remoteUpdate.c
